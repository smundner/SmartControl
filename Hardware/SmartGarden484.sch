File: Hardware/SmartGarden484.sch (KiCad schematic (older format))
At the start: 42 parts

Commit message: backup
Parts:
- gave numbers to parts that had none: 42
